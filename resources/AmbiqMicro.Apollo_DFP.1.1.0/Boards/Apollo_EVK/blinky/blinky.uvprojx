# Keil uVision project blinky.uvprojx, settings and files
target Blinky (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: APOLLO512-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.0.0
  cpu: IRAM(0x10000000,0x10000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: blinky
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  group source
    ./: blinky.c
software components: CMSIS:CORE 3.40.0, Device:Startup 0.2.2
